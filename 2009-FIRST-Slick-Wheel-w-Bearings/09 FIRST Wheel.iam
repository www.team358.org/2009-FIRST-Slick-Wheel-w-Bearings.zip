# Autodesk Inventor assembly: 09 FIRST Wheel
## iProperties
Created: 2009-03
Part Number: 09 FIRST Wheel
Document SubType Name: Assembly
Designer: Pat
Author: Pat
