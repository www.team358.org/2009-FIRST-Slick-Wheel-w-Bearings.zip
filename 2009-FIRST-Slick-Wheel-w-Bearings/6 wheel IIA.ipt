# Autodesk Inventor part: 6 wheel IIA
## iProperties
Created: 2009-03
Part Number: 6 wheel IIA
Document SubType Name: Modeling
Designer: Pat
Density: 1 g/cm^3
Author: Pat
